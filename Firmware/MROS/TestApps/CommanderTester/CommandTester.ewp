# IAR project CommandTester.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 300
  General.SCRStackSize: 64
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.IExtraOptions: --string_literals_in_flash
  ICCAVR.newCCIncludePaths: f:\Projects\[Drivers]\C\mros\TestApps\CommanderTester; f:\Projects\[Drivers]\C\mros
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm32.xcl
  group (top)
    ../../Commander/: Commander.c
    ./: main.c
  group MROS
    ../../Kernel/: Kernel.c MessageQueue.c TaskManagement.c Timer.c
    ../../: strings.c
  group MROS/FileStore
    ../../FileStore/: FileStore.c InternalEEPROM.c
  group MROS/Peripherals
    ../../Peripherals/: UART.c
  group MROS/Terminal
    ../../Terminal/: Terminal.c
