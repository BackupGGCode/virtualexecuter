# IAR project VXInterpreter.ewp, settings and files
configuration Debug (AVR, debug)
  General.LCHeapSize: 0x10
  General.SCCStackSize: 0x20
  General.SCRStackSize: 16
  General.LCTinyHeapSize: 0x10
  General.LCNearHeapSize: 0x20
  General.LCFarHeapSize: 0x1000
  General.LCHugeHeapSize: 0x1000
  ICCAVR.CCStdIncludePaths: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  XLINK.XclFile: lnk0t.xcl
configuration Release (AVR)
  as the first configuration, except:
  General.SCCStackSize: 0x130
  General.SCRStackSize: 60
  ICCAVR.CCDefines: NDEBUG
  ICCAVR.IExtraOptions: --string_literals_in_flash; --force_switch_type 1
  ICCAVR.newCCIncludePaths: f:\Projects\[Drivers]\C\MROS; f:\Projects\Virtual eXecuter\code.google\Firmware\VXInterpreter
  XLINK.XclFile: $TOOLKIT_DIR$\src\template\cfgm64.xcl
  group (top)
    ./: DataFlash.c DRAM.c main.c Terminal.c
  group MROS
    ../../../../[Drivers]/C/MROS/: mem.c strings.c
  group MROS/Commander
    ../../../../[Drivers]/C/MROS/Commander/: Commander.c
  group MROS/FileStore
    ../../../../[Drivers]/C/MROS/FileStore/: FileStore.c
  group MROS/Kernel
    ../../../../[Drivers]/C/MROS/Kernel/: Kernel.c MemoryManagement.c TaskManagement.c Timer.c
  group MROS/Peripherals
    ../../../../[Drivers]/C/MROS/Peripherals/: InternalEEPROM.c UART.c
  group VX
    VX/: VX_MachineManagement.c VX_ProcessExecuter.c VX_ProcessManagement.c
