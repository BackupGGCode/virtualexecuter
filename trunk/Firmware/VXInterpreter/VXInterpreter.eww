<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>F:\Projects\Virtual eXecuter\code.google\Firmware\VXInterpreter\VXInterpreter.ewp</path>
  </project>
  <batchBuild/>
</workspace>


